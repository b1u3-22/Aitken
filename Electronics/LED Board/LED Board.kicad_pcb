# Repository b1u3-22/Aitken (continued)

## KiCad design Electronics/Aitken.kicad_pcb

Board: 4 copper layers, 55.0 x 65.0 mm, 119 parts (30 on the bottom side), 82 nets.

Parts:
AE1: 2450AT18x0100; Johanson_2450AT18x100
BT2: BATT; JST_SH_BM02B-SRSS-TB_1x02-1MP_P1.00mm_Vertical
C1, C2, C3, C6, C7, C23, C24, C27, C28, C36: 100n; C_0402_1005Metric
C4, C5, C19, C21, C31: 10u; C_0603_1608Metric
C8, C9: 3p3; C_0402_1005Metric
C10, C11: 11p; C_0402_1005Metric
C12, C16, C17, C18: 10u; C_0805_2012Metric
C13, C29, C30: 1u; C_0603_1608Metric
C14: 4u7; C_0603_1608Metric
C15: 22n; C_0603_1608Metric
C20, C22, C32: 470n; C_0805_2012Metric
C26: 1u; CP_Elec_4x4.5
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: LED; LED_EAHC2835WD6
D37: SMF22CA; D_SOD-123F
F2: 2016L500DR; Fuse_2010_5025Metric
H1: M1; MountingHole_3.2mm_M3_Pad_Via
H2: M2; MountingHole_3.2mm_M3_Pad_Via
H3: M3; MountingHole_3.2mm_M3_Pad_Via
H4: M4; MountingHole_3.2mm_M3_Pad_Via
J1: USB_C_Receptacle_USB2.0; GCT_USB4085-GF-A_REVB
J2: OLED_CONN; PinHeader_1x04_P2.54mm_Vertical
J3: UART_CONN; PinHeader_1x04_P2.54mm_Vertical
JP1: ACC_ADD; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP2: MAG_ADD; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L1, L2: 2n2; L_0402_1005Metric
L3: 1u; L_1210_3225Metric
L4, L5, L6: 10u; IND_XFL4020-102MEC
R1: 22R; R_0402_1005Metric
R2, R15, R16, R17, R18, R28, R29, R30, R31, R32, R33, R34: 5k1; R_0402_1005Metric
R3, R5, R6: 10k; R_0402_1005Metric
R4: 100k; R_0603_1608Metric
R7, R8, R9: 1R3; R_0805_2012Metric
R36, R37: 470R; R_0402_1005Metric
SW2: PEC12; RotaryEncoder_Bourns_Vertical_PEC12R-3xxxF-Sxxxx
SW4: MCU_EN; SW_Push_1P1T_NO_6x6mm_H9.5mm
TH1: BATT_TEMP; R_0402_1005Metric
TP1: TP_VBUS_DIR; TestPoint_Pad_D2.0mm
TP2: TP_VSYS; TestPoint_Pad_D2.0mm
TP5: TP_3V3; TestPoint_Pad_D2.0mm
U1: ESP32-C4FH4; QFN-32-1EP_5x5mm_P0.5mm_EP3.7x3.7mm
U2: MP2722; MP2722GRH0000Z
U3: TPD4E02B04DQA; USON-10_2.5x1.0mm_P0.5mm
U4: LIS3MDL; LGA-12_2x2mm_P0.5mm
U5: LSM6DS3; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U6: NCP186AMX330TAG; PSON40P160X120X45-9N
U7, U8, U9: KTD2801; DFN-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
Y1: 40MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C23.1, C24.1, C26.1, C27.1, C29.1, J2.1, J3.4, L1.2, R2.2, R15.1, R16.1, R17.1, R18.1, R28.1, R29.1, R31.1, R32.1, R33.1, TP5.1, U1.11 (VDD3P3_RTC), U1.17 (VDD3P3_CPU), U1.31 (VDDA), U1.32 (VDDA), U4.5 (VDD), U4.6 (VDDIO), U5.5 (VDDIO), U5.8 (VDD), U6.1 (OUT), U6.2 (OUT), U6.4 (FB/ADJ)
/MCU/CHIP_EN: C36.2, R2.1, SW4.2, U1.7 (CHIP_EN)
/MCU/ENC_A: R31.2, SW2.A, U1.15 (GPIO9)
/MCU/ENC_B: R32.2, SW2.B, U1.16 (GPIO10)
/MCU/ENC_S: R30.1, SW2.S1, U1.8 (GPIO3)
/MCU/ESP32_RX: R36.2, U1.27 (U0RXD)
/MCU/ESP32_TX: R37.2, U1.28 (U0TXD)
/MCU/LNA_IN: C8.1, L2.2, U1.1 (LNA_IN)
/MCU/XTAL_IN: C11.1, R1.1, Y1.3
/MCU/XTAL_N: C10.1, U1.29 (XTAL_N), Y1.1
/MCU/XTAL_P: R1.2, U1.30 (XTAL_P)
/Power management/USB_D+: J1.A6 (D+), J1.B6 (D+), U3.4 (IO3)
/Power management/USB_D-: J1.A7 (D-), J1.B7 (D-), U3.5 (IO4)
/Sensors/ACC_ADD: JP1.2 (B), R16.2, U5.1 (SDO/SA0)
/Sensors/MAG_ADD: JP2.2 (B), R18.2, U4.9 (SDO/SA1)
CC1: U2.1 (CC1), U3.9 (NC)
CC2: U2.22 (CC2), U3.10 (NC)
D+: U1.26 (GPIO19), U3.6 (NC)
D-: U1.25 (GPIO18), U3.7 (NC)
Earth: BT2.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.2, C22.1, C23.2, C24.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C36.1, D37.1 (A1), H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.2, J3.1, JP1.1 (A), JP2.1 (A), R3.1, R7.2, R8.2, R9.2, R30.2, R34.2, SW2.C, SW4.1, TH1.2, U1.33 (GND), U2.5 (PGND), U2.18 (AGND), U3.3 (G), U3.8 (G), U4.2 (GND), U4.3 (GND), U4.12 (GND), U5.6 (GND), U5.7 (GND), U6.3 (N/C), U6.5 (GND), U6.9 (EPAD), U7.5 (GND), U8.5 (GND), U9.5 (GND), Y1.2, Y1.4
L_CONT: R34.1, U1.14 (GPIO8), U7.1 (CTRL), U8.1 (CTRL), U9.1 (CTRL)
unnamed: AE1.1 (A), C9.1, L2.1
unnamed: BT2.1 (+), F2.1
unnamed: C7.1, L1.1, U1.2 (VDD3P3), U1.3 (VDD3P3)
unnamed: C20.2, D1.2 (A), U7.3 (VOUT)
unnamed: D1.1 (K), D2.2 (A)
unnamed: D2.1 (K), D3.2 (A)
unnamed: D3.1 (K), D4.2 (A)
unnamed: D4.1 (K), D5.2 (A)
unnamed: D5.1 (K), D6.2 (A)
unnamed: D6.1 (K), D7.2 (A)
unnamed: D7.1 (K), D8.2 (A)
unnamed: D8.1 (K), D9.2 (A)
unnamed: D9.1 (K), D10.2 (A)
unnamed: D10.1 (K), R7.1, U7.4 (FB)
unnamed: C22.2, D11.2 (A), U8.3 (VOUT)
unnamed: D11.1 (K), D12.2 (A)
unnamed: D12.1 (K), D13.2 (A)
unnamed: D13.1 (K), D14.2 (A)
unnamed: D14.1 (K), D15.2 (A)
unnamed: D15.1 (K), D16.2 (A)
unnamed: D16.1 (K), D17.2 (A)
unnamed: D17.1 (K), D18.2 (A)
unnamed: D18.1 (K), D19.2 (A)
unnamed: D19.1 (K), D20.2 (A)
unnamed: D20.1 (K), R8.1, U8.4 (FB)
unnamed: C32.2, D21.2 (A), U9.3 (VOUT)
unnamed: D21.1 (K), D22.2 (A)
unnamed: D22.1 (K), D23.2 (A)
unnamed: D23.1 (K), D24.2 (A)
unnamed: D24.1 (K), D25.2 (A)
unnamed: D25.1 (K), D26.2 (A)
unnamed: D26.1 (K), D27.2 (A)
unnamed: D27.1 (K), D28.2 (A)
unnamed: D28.1 (K), D29.2 (A)
unnamed: D29.1 (K), D30.2 (A)
unnamed: D30.1 (K), R9.1, U9.4 (FB)
unnamed: J1.A5 (CC1), U3.2 (IO2)
unnamed: J1.B5 (CC2), U3.1 (IO1)
unnamed: R33.2, SW2.S2
unnamed: C18.1, F2.2, U2.12 (BATTSNS), U2.14 (BATT)
unnamed: C15.2, U2.6 (BST)
unnamed: R4.1, TH1.1, U2.10 (NTC)
unnamed: R5.1, U2.9 (PG)
unnamed: C12.1, U2.3 (PMID)
unnamed: R6.1, U2.11 (STAT)
unnamed: C15.1, L3.1, U2.4 (SW)
unnamed: C14.1, R5.2, R6.2, U2.19 (VCC)
unnamed: R4.2, U2.7 (VRNTC)
unnamed: R3.2, U2.17 (~RST)
unnamed: C28.1, U4.4 (C1)
unnamed: R17.2, U4.10 (~CS)
unnamed: R15.2, U5.12 (CS)
unnamed: L4.2, U7.6 (LX)
unnamed: L5.2, U8.6 (LX)
unnamed: L6.2, U9.6 (LX)
RX: J3.3, R36.1
SCL: J2.3, R28.2, U1.9 (MTMS), U2.16 (SCL), U4.1 (SCL/SPC), U5.14 (SDA)
SDA: J2.4, R29.2, U1.10 (MTDI), U2.15 (SDA), U4.11 (SDA/SDI/SDO), U5.13 (SCL)
TX: J3.2, R37.1
VBUS: C13.1, D37.2 (A2), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP1.1, U2.2 (IN)
VSYS: C16.1, C17.1, C19.1, C21.1, C30.1, C31.1, L3.2, L4.1, L5.1, L6.1, TP2.1, U2.13 (SYS), U6.6 (EN), U6.7 (IN), U6.8 (IN), U7.2 (VIN), U8.2 (VIN), U9.2 (VIN)

## Commit log

2023-10-29 Most of schematics
    Sensor, Lights and MCU schematics are complete
2023-10-29 All schematics complete
    Completed battery, power-path and USB-PD management. 3V3 and V_LIGHTS rail. ESP32-C3 together with Magnetometer, Accelerometer and Gyroscope. And the LED lights
2023-10-29 Better README
    Better README with short list of features
2023-10-29 Clean up
    Deleted useless files in wrong directory
2023-10-29 Added schematics PDF
    Created folder for Documents, and added schematic PDF
2023-10-30 Schematic update
    Added correct values for crystal capacitors, added net labels and minor cleanup
2023-10-30 Schematic document update
    Added new schematic PDF to Documents
2023-11-01 Power and lights update
    Changed STUSB4500 + BQ25895 to MP2722. Changed Lights power supply, now it's split up to 3 LED drivers - KTD2801 as 10s1p. Added fuses to each battery. Added ESD protection. Fixed CHIP_EN pin name on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
2023-11-01 Updated schematic doc
    Updated schematic to reflect current changes
2023-11-05 Schematic update
    Removed one battery, changed battery fuse to correct one. Fixed OLED connector
2023-11-29 PCB Layout mostly completed
    Still have to finish LEDs layout on back side
2023-11-29 Basic PCB layout finished
2023-11-30 PCB Optimalizations
2023-11-30 Auto stash before merge of "latest" and "origin/latest"
2023-11-30 Changed USB port
2023-12-03 Cosmetic PCB changes
    Added silkscreen labels and logo. Other minor fixes
2023-12-03 Fixed antenna
2023-12-04 Fixed crystal
2023-12-04 Fixes
2023-12-04 Minor fixes
2023-12-18 New shiny README
2024-09-13 fix!: Version 2
    Project changes:
    Aitken is now split into two PCBs, one for LEDs only and the other one with the rest of the electronics
    Schematic/Component changes:
    Changed main power IC to MAX77972 from MP2722
    Changed MCU to ESP32-S3 from ESP32-C3
    Changed Chip antenna to PCB one
2024-09-13 docs: updated README to match hardware changes
2024-09-13 docs: updated schematics for main board
