# Repository b1u3-22/Aitken

File README.md:

# What is Aitken
Aitken is small light, that was designed to help astronomers to see better during night sky observations without losing their night vision. 

## Name
The name **Aitken** was chosen after [Robert Grand Aitken](https://en.wikipedia.org/wiki/Robert_Grant_Aitken) who discovered the [Red Rectangle Nebula](https://en.wikipedia.org/wiki/Red_Rectangle_Nebula). The shape of the nebula was also inspiration when creating logo for this project

## Features
### USB-C
Used for two-way charging with USB-PD. It can also be used to program the ESP32-S3 microcontroller inside.

### Controls
Aitken features rotatory encoder that is used to either change the light intensity and to navigate the menu. Above that is small OLED screen. 

### Sensors
Featuring accelerometer and gyroscope enables Aitken to be controlled via gestures. It also has 3-axis magnetometer.

### Lights
The board has 30 LEDs with all of them being red in the 620 - 630nm range with luminous flux of around 4 lumens each. 

## Project status

| Status                     	| Action           	 | ETA       	 |
|----------------------------	|------------------	 |-----------	 |
| ✅ Done                       | Schematic design 	 | Done      	 |
| ❎ In progress 		        | PCB design         | 16.09.2024	 |
| ❎ Waiting for PCB            | PCB test         	 |           	 |
| ❎ Waiting for PCB 		    | Firmware         	 |           	 |

## Technical details
### MCU
The MCU used is [ESP32-S3FN8](https://www.espressif.com/sites/default/files/documentation/esp32-s3_datasheet_en.pdf) with integrated 8MB flash, 2.4GHz Wi-Fi and Bluetooth 5.0 LE.

### Sensors 
For accelerometer I decided to use [LSM6DSOTR](https://www.st.com/resource/en/datasheet/lsm6dso.pdf).
The magnetometer used is [LIS3MDLTR](https://www.st.com/content/ccc/resource/technical/document/datasheet/54/2a/85/76/e3/97/42/18/DM00075867.pdf/files/DM00075867.pdf/jcr:content/translations/en.DM00075867.pdf)

### Power
For USB-PD controller, battery charger and power bus manager I chose [MAX77972](https://www.analog.com/media/en/technical-documentation/data-sheets/max77972.pdf) mainly for the ability
to program the charge voltage and current using resistors and the integrated battery fuel gauge.
Power for lights is provided from [AP3031](https://www.diodes.com/assets/Datasheets/AP3031.pdf) and 3V3 power rail is powered from [NCP186](https://www.onsemi.com/pdf/datasheet/ncp186-d.pdf)

### PCB
Aitken is made out of 2 separate boards. The first one has 4 layer stack up with main circutry and battery holders. The second one is 1 layer aluminium board with just the LEDs and connector.

## KiCad design Electronics/LED Board/LED Board.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: CLS6B-FKW; LED_RGB_5050-6
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: LIGHTS Connector; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical

Connections:
GND_1: D10.1 (AB), D10.2 (KB), D10.3 (AR), J1.2
GND_2: D20.1 (AB), D20.2 (KB), D20.3 (AR), J1.4
GND_3: D30.1 (AB), D30.2 (KB), D30.3 (AR), J1.6
unnamed: D1.1 (AB), D2.6 (KR)
unnamed: D1.3 (AR), D2.4 (KR)
unnamed: D1.2 (KB), D2.5 (AG)
unnamed: D2.1 (AB), D3.6 (KR)
unnamed: D2.3 (AR), D3.4 (KR)
unnamed: D2.2 (KB), D3.5 (AG)
unnamed: D3.1 (AB), D4.6 (KR)
unnamed: D3.3 (AR), D4.4 (KR)
unnamed: D3.2 (KB), D4.5 (AG)
unnamed: D4.1 (AB), D5.6 (KR)
unnamed: D4.3 (AR), D5.4 (KR)
unnamed: D4.2 (KB), D5.5 (AG)
unnamed: D5.1 (AB), D6.6 (KR)
unnamed: D5.3 (AR), D6.4 (KR)
unnamed: D5.2 (KB), D6.5 (AG)
unnamed: D6.1 (AB), D7.6 (KR)
unnamed: D6.3 (AR), D7.4 (KR)
unnamed: D6.2 (KB), D7.5 (AG)
unnamed: D7.1 (AB), D8.6 (KR)
unnamed: D7.3 (AR), D8.4 (KR)
unnamed: D7.2 (KB), D8.5 (AG)
unnamed: D8.1 (AB), D9.6 (KR)
unnamed: D8.3 (AR), D9.4 (KR)
unnamed: D8.2 (KB), D9.5 (AG)
unnamed: D9.1 (AB), D10.6 (KR)
unnamed: D9.3 (AR), D10.4 (KR)
unnamed: D9.2 (KB), D10.5 (AG)
unnamed: D11.1 (AB), D12.6 (KR)
unnamed: D11.3 (AR), D12.4 (KR)
unnamed: D11.2 (KB), D12.5 (AG)
unnamed: D12.1 (AB), D13.6 (KR)
unnamed: D12.3 (AR), D13.4 (KR)
unnamed: D12.2 (KB), D13.5 (AG)
unnamed: D13.1 (AB), D14.6 (KR)
unnamed: D13.3 (AR), D14.4 (KR)
unnamed: D13.2 (KB), D14.5 (AG)
unnamed: D14.1 (AB), D15.6 (KR)
unnamed: D14.3 (AR), D15.4 (KR)
unnamed: D14.2 (KB), D15.5 (AG)
unnamed: D15.1 (AB), D16.6 (KR)
unnamed: D15.3 (AR), D16.4 (KR)
unnamed: D15.2 (KB), D16.5 (AG)
unnamed: D16.1 (AB), D17.6 (KR)
unnamed: D16.3 (AR), D17.4 (KR)
unnamed: D16.2 (KB), D17.5 (AG)
unnamed: D17.1 (AB), D18.6 (KR)
unnamed: D17.3 (AR), D18.4 (KR)
unnamed: D17.2 (KB), D18.5 (AG)
unnamed: D18.1 (AB), D19.6 (KR)
unnamed: D18.3 (AR), D19.4 (KR)
unnamed: D18.2 (KB), D19.5 (AG)
unnamed: D19.1 (AB), D20.6 (KR)
unnamed: D19.3 (AR), D20.4 (KR)
unnamed: D19.2 (KB), D20.5 (AG)
unnamed: D21.1 (AB), D22.6 (KR)
unnamed: D21.3 (AR), D22.4 (KR)
unnamed: D21.2 (KB), D22.5 (AG)
unnamed: D22.1 (AB), D23.6 (KR)
unnamed: D22.3 (AR), D23.4 (KR)
unnamed: D22.2 (KB), D23.5 (AG)
unnamed: D23.1 (AB), D24.6 (KR)
unnamed: D23.3 (AR), D24.4 (KR)
unnamed: D23.2 (KB), D24.5 (AG)
unnamed: D24.1 (AB), D25.6 (KR)
unnamed: D24.3 (AR), D25.4 (KR)
unnamed: D24.2 (KB), D25.5 (AG)
unnamed: D25.1 (AB), D26.6 (KR)
unnamed: D25.3 (AR), D26.4 (KR)
unnamed: D25.2 (KB), D26.5 (AG)
unnamed: D26.1 (AB), D27.6 (KR)
unnamed: D26.3 (AR), D27.4 (KR)
unnamed: D26.2 (KB), D27.5 (AG)
unnamed: D27.1 (AB), D28.6 (KR)
unnamed: D27.3 (AR), D28.4 (KR)
unnamed: D27.2 (KB), D28.5 (AG)
unnamed: D28.1 (AB), D29.6 (KR)
unnamed: D28.3 (AR), D29.4 (KR)
unnamed: D28.2 (KB), D29.5 (AG)
unnamed: D29.1 (AB), D30.6 (KR)
unnamed: D29.3 (AR), D30.4 (KR)
unnamed: D29.2 (KB), D30.5 (AG)
SIG_1: D1.4 (KR), D1.5 (AG), D1.6 (KR), J1.1
SIG_2: D11.4 (KR), D11.5 (AG), D11.6 (KR), J1.3
SIG_3: D21.4 (KR), D21.5 (AG), D21.6 (KR), J1.5

Notes on the sheet:
LEDs used: GETIAN GT-M50503R620-0 If other type is used instead, the R_{ISET} resistor of each lights supply on the main board has to be changed accordingly

Board: 2 copper layers, 35 parts (1 on the bottom side), 87 nets, no tracks yet.

## KiCad design Electronics/Main Board/Main Board.kicad_pcb

Parts:
C29, C30, C31, C32, C33, C34: 0u47; C_0402_1005Metric
D2, D13, D24: SD103AWSG; D_SOD-323
L5, L6, L7: 0u47; L_2512_6332Metric
R11, R13, R15: 10k; R_0402_1005Metric
R12, R14, R16: 3R3 1%; R_0805_2012Metric
U5, U6, U7: AP3031

Connections:
/Lights/L_1_SW: D2.2 (A), L5.2, U5.1 (SW)
/Lights/L_2_SW: D13.2 (A), L6.2, U6.1 (SW)
/Lights/L_3_SW: D24.2 (A), L7.2, U7.1 (SW)
Earth: C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, U5.2 (GND), U6.2 (GND), U7.2 (GND); also elsewhere on the board
LIGHT_1_GND: R12.1, U5.3 (FB); also elsewhere on the board
LIGHT_1_PWM: R11.1, U5.4 (CTRL); also elsewhere on the board
LIGHT_1_SIG: C29.1, D2.1 (K), U5.5 (OV); also elsewhere on the board
LIGHT_2_GND: R14.1, U6.3 (FB); also elsewhere on the board
LIGHT_2_PWM: R13.1, U6.4 (CTRL); also elsewhere on the board
LIGHT_2_SIG: C32.1, D13.1 (K), U6.5 (OV); also elsewhere on the board
LIGHT_3_GND: R16.1, U7.3 (FB); also elsewhere on the board
LIGHT_3_PWM: R15.1, U7.4 (CTRL); also elsewhere on the board
LIGHT_3_SIG: C34.1, D24.1 (K), U7.5 (OV); also elsewhere on the board
VSYS: C30.1, C31.1, C33.1, L5.1, L6.1, L7.1, U5.6 (VIN), U6.6 (VIN), U7.6 (VIN); also elsewhere on the board

Notes on the sheet:
R_{ISET} = 200mV / I_{LED}

Parts:
C12, C43, C45: 10n; C_0402_1005Metric
C26: 0u1; C_0402_1005Metric
C38, C39, C42, C44: 100n; C_0402_1005Metric
C40, C41: 1u; C_0402_1005Metric
D35: LED_Small; D_0603_1608Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J2: OLED; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: JTAG; PinSocket_1x04_P2.54mm_Vertical
J4: UART; PinSocket_1x04_P2.54mm_Vertical
J5: Lights connector; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R5: 0R; R_0402_1005Metric
R19, R20, R21, R22, R23, R24, R25, R26: 10k; R_0402_1005Metric
R27: 2k; R_0402_1005Metric
SW1: RESET; SW_SPST_PTS647_Sx50
SW2: RotaryEncoder_Switch; RotaryEncoder_Bourns_Vertical_PEC12R-3x17F-Sxxxx
U8: LSM6DSOTR; LSM6DSO
U9: LIS3MDL; LGA-12_2x2mm_P0.5mm

Connections:
+3V3: C38.1, C39.1, C40.1, C41.1, C44.1, C45.1, J2.2, J4.1, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, SW2.S1, U8.5 (VDDIO), U8.8 (VDD), U9.5 (Vdd), U9.6 (Vdd_IO); also elsewhere on the board
/Peripherals/ACC_CS: R22.1, U8.12 (CS)
/Peripherals/ACC_SD0: R23.1, U8.1 (SDO/SA0)
/Peripherals/GYR_BYP: C42.1, U9.4 (C1)
/Peripherals/GYR_CS: R24.1, U9.10 (~CS)
/Peripherals/GYR_SD0: R25.1, U9.9 (SDO/SA1)
ENC_A: C43.1, R20.1, SW2.A; also elsewhere on the board
ENC_B: C12.1, R21.1, SW2.B; also elsewhere on the board
ENC_SWITCH: C45.2, R19.2, SW2.S2; also elsewhere on the board
Earth: C12.2, C26.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, D35.1 (K), H1.1, H2.1, H3.1, H4.1, J2.1, J4.4, R19.1, R26.2, SW1.1, SW2.C, U8.6 (GND), U8.7 (GND), U9.2 (GND), U9.3 (GND), U9.12 (GND); also elsewhere on the board
INT_GYRACC_1: U8.4 (INT1); also elsewhere on the board
INT_GYRACC_2: U8.9 (INT2); also elsewhere on the board
INT_MAG: U9.7 (INT); also elsewhere on the board
LED: R26.1, R27.2; also elsewhere on the board
LIGHT_1_GND: J5.2; also elsewhere on the board
LIGHT_1_SIG: J5.1; also elsewhere on the board
LIGHT_2_GND: J5.4; also elsewhere on the board
LIGHT_2_SIG: J5.3; also elsewhere on the board
LIGHT_3_GND: J5.6; also elsewhere on the board
LIGHT_3_SIG: J5.5; also elsewhere on the board
MCU_EN: R5.1; also elsewhere on the board
unnamed: C26.1, R5.2, SW1.2
unnamed: D35.2 (A), R27.1
RXD: J4.3; also elsewhere on the board
SCL: J2.3, U8.13 (SCL), U9.1 (SCL/SPC); also elsewhere on the board
SDA: J2.4, U8.14 (SDA), U9.11 (SDA/SDI/SDO); also elsewhere on the board
TCK: J3.4; also elsewhere on the board
TDI: J3.2; also elsewhere on the board
TDO: J3.3; also elsewhere on the board
TMS: J3.1; also elsewhere on the board
TXD: J4.2; also elsewhere on the board

Notes on the sheet:
Reset button
Accelerometer/Gyroscope
Magnetometer
Debug LED
Rotary encoder
OLED screen connector
JTAG connector
Lights connector
UART connector

Parts:
BT1, BT2: Li-Ion cell; BatteryHolder_Keystone_1042_1x18650
C1, C2, C6, C7: 2u2; C_0402_1005Metric
C3: 22u; C_0603_1608Metric
C4: 0u1; C_0402_1005Metric
C5, C8, C9: 10u; C_0603_1608Metric
C35: 100n; C_0402_1005Metric
C36, C37: 1u; C_0402_1005Metric
D1: SMF22CA; D_SMF
F1: MF-USML700/6-2; Fuse_1210_3225Metric
IC1: MAX77972; Manufacturer_Part_Number MAX77972EWX+T
J1: USB-C Receptacle; USB_C_Receptacle_GCT_USB4085
JP1: JMP_DATAMUX_DIS; PinHeader_1x02_P2.54mm_Vertical
L1: 0u47; L_2512_6332Metric
R1, R2: 4k42 1%; R_0402_1005Metric
R3, R17, R18: 10k; R_0402_1005Metric
TH1: 10k; R_0402_1005Metric
TP1: TP_CHG_IN; TestPoint_Pad_D2.5mm
TP2: TP_CHG_STAT; TestPoint_Pad_D2.5mm
U1: TPD4E05U06DQA; USON-10_2.5x1.0mm_P0.5mm
U3: NX3DV221GM_115; NX3DV221GM
U4: NCP186AMX330TAG

Connections:
+3V3: C35.1, C37.1, R3.1, R17.1, U3.10 (VCC), U4.1 (OUT), U4.2 (OUT), U4.4 (FB/ADJ); also elsewhere on the board
/Power/BATT: C5.1, C7.1, F1.2, IC1.C4 (BATTSP_/CSN), IC1.C5 (CSP), IC1.D4 (BATT_1), IC1.D5 (BATT_2), IC1.D6 (BATT_3)
/Power/BATT_FUSE: BT1.1 (+), BT2.1 (+), F1.1
/Power/BST: C4.1, IC1.F1 (BST)
/Power/BYP: C3.2, IC1.C1 (BYP_1), IC1.C2 (BYP_2)
/Power/CHGEN: IC1.E3 (CHGEN), R17.2
/Power/CHG_INOK: IC1.C3 (INOKB), TP1.1
/Power/CHG_STAT: IC1.A3 (STAT), TP2.1
/Power/DATA_OPEN: R18.1, U3.6 (*OE)
/Power/ICHG: IC1.A2 (ICHG), R2.1
/Power/LX: C4.2, IC1.D1 (LX_1), IC1.D2 (LX_2), IC1.D3 (LX_3), L1.1
/Power/PVL: C6.1, IC1.F2 (PVL)
/Power/THM: IC1.A4 (THM), TH1.1
/Power/VCHG: IC1.A1 (VCHG), R1.1
/Power/VDD: C2.1, IC1.A5 (VDD)
CC1: IC1.F3 (CC1), U1.10 (NC)
CC1_USB: J1.A5 (CC1), U1.1 (D1+)
CC2: IC1.F4 (CC2), U1.9 (NC)
CC2_USB: J1.B5 (CC2), U1.2 (D1-)
D+: U1.7 (NC), U3.8 (D+)
D-: U1.6 (NC), U3.7 (D-)
DATAMUX_SEL: IC1.B3 (DATAMUX), JP1.2 (B), R3.2, U3.9 (S)
D_CHG+: IC1.F5 (DP), U3.3 (2D+)
D_CHG-: IC1.F6 (DN), U3.4 (2D-)
D_MCU+: U3.1 (1D+); also elsewhere on the board
D_MCU-: U3.2 (1D-); also elsewhere on the board
D_USB+: J1.A6 (D+), J1.B6 (D+), U1.4 (D2+)
D_USB-: J1.A7 (D-), J1.B7 (D-), U1.5 (D2-)
Earth: BT1.2 (-), BT2.2 (-), C1.2, C2.2, C3.1, C5.2, C6.2, C7.2, C8.2, C9.2, C35.2, C36.2, C37.2, D1.1 (A1), IC1.A6 (GND), IC1.B5 (BATTSN), IC1.E1 (PGND_1), IC1.E2 (PGND_2), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), JP1.1 (A), R1.2, R2.2, R18.2, TH1.2, U1.3 (GND), U1.8 (GND), U3.5 (GND), U4.3 (N/C), U4.5 (GND), U4.9 (EPAD); also elsewhere on the board
INT_CHG: IC1.B4 (ALRT); also elsewhere on the board
SCL: IC1.B6 (SCL); also elsewhere on the board
SDA: IC1.C6 (SDA); also elsewhere on the board
VBUS: C1.1, D1.2 (A2), IC1.B1 (CHGIN_1), IC1.B2 (CHGIN_2), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
VSYS: C8.1, C9.1, C36.1, IC1.E4 (SYS_1), IC1.E5 (SYS_2), IC1.E6 (SYS_3), L1.2, U4.6 (EN), U4.7 (IN), U4.8 (IN); also elsewhere on the board

Notes on the sheet:
3V3 rail
USB-C Connector
Battery charger
USB Multiplexer
Resistor values correspond to 1000mA charge current and 4.47V of charge voltage with empty battery voltage being 3.3V
When this jumper (JP1) is bridged, multiplexer will always connect data lines to MCU

Parts:
AE1: PCB Antenna; Texas_SWRA117D_2.4GHz_Left
C10: 2p6; C_0402_1005Metric
C11: 2p; C_0402_1005Metric
C13, C14, C17, C18, C19, C20, C23, C25: 0u1; C_0402_1005Metric
C15, C22: 1u; C_0402_1005Metric
C16: 10u; C_0603_1608Metric
C21: 10n; C_0402_1005Metric
C24: 22u; C_0603_1608Metric
C27, C28: 12p; C_0402_1005Metric
L2: 3n3; L_0402_1005Metric
L4: 2n; L_0402_1005Metric
R4, R9, R10: 10k; R_0402_1005Metric
R6: 499R; R_0402_1005Metric
R7, R8: 0R; R_0402_1005Metric
U2: ESP32-S3FN8; QFN-56-1EP_7x7mm_P0.4mm_EP4x4mm
Y2: 40MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, L4.1, R4.2, R9.2, R10.2, U2.20 (VDD3P3_RTC), U2.29 (VDD_SPI), U2.46 (VDD3P3_CPU), U2.55 (VDDA), U2.56 (VDDA); also elsewhere on the board
/MCU/ANTENNA: C10.1, L2.1, U2.1 (LNA_IN)
/MCU/RXD_MCU: R6.2, U2.50 (U0RXD)
/MCU/USB_D+: R8.2, U2.26 (GPIO20/USB_D+)
/MCU/USB_D-: R7.2, U2.25 (GPIO19/USB_D-)
/MCU/VDD3P3: C13.1, L4.2, U2.2 (VDD3P3), U2.3 (VDD3P3)
/MCU/XTAL_N: C28.1, U2.53 (XTAL_N), Y2.1
/MCU/XTAL_P: C27.2, U2.54 (XTAL_P), Y2.3
D_MCU+: R8.1; also elsewhere on the board
D_MCU-: R7.1; also elsewhere on the board
ENC_A: U2.39 (GPIO34); also elsewhere on the board
ENC_B: U2.40 (GPIO35); also elsewhere on the board
ENC_SWITCH: U2.41 (GPIO36); also elsewhere on the board
Earth: AE1.2 (Shield), C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C27.1, C28.2, U2.57 (GND), Y2.2, Y2.4; also elsewhere on the board
INT_CHG: U2.19 (GPIO14); also elsewhere on the board
INT_GYRACC_1: U2.17 (GPIO12); also elsewhere on the board
INT_GYRACC_2: U2.16 (GPIO11); also elsewhere on the board
INT_MAG: U2.15 (GPIO10); also elsewhere on the board
LED: U2.18 (GPIO13); also elsewhere on the board
LIGHT_1_PWM: U2.9 (GPIO4); also elsewhere on the board
LIGHT_2_PWM: U2.10 (GPIO5); also elsewhere on the board
LIGHT_3_PWM: U2.11 (GPIO6); also elsewhere on the board
MCU_EN: C25.1, R4.1, U2.4 (CHIP_PU); also elsewhere on the board
unnamed: AE1.1 (A), C11.1, L2.2
RXD: R6.1; also elsewhere on the board
SCL: R10.1, U2.43 (GPIO38); also elsewhere on the board
SDA: R9.1, U2.42 (GPIO37); also elsewhere on the board
TCK: U2.44 (MTCK); also elsewhere on the board
TDI: U2.47 (MTDI); also elsewhere on the board
TDO: U2.45 (MTDO); also elsewhere on the board
TMS: U2.48 (MTMS); also elsewhere on the board
TXD: U2.49 (U0TXD); also elsewhere on the board

Board: 4 copper layers, 90.0 x 90.0 mm, 125 parts (8 on the bottom side), 75 nets.

Other parts of the board:
kibuzzard-66E45DB7: G***; kibuzzard-66E45DB7
kibuzzard-66E45E5B: G***; kibuzzard-66E45E5B
kibuzzard-66E45E6A: G***; kibuzzard-66E45E6A
kibuzzard-66E45EEC: G***; kibuzzard-66E45EEC
kibuzzard-66E45F18: G***; kibuzzard-66E45F18
kibuzzard-66E462E1: G***; kibuzzard-66E462E1
kibuzzard-66E4619D, kibuzzard-66E4619D#2: G***; kibuzzard-66E4619D
kibuzzard-66E4636A: G***; kibuzzard-66E4636A
kibuzzard-66E4638B: G***; kibuzzard-66E4638B
kibuzzard-66E46053: G***; kibuzzard-66E46053
kibuzzard-66E46148: G***; kibuzzard-66E46148
